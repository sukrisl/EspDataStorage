## example/sdkconfig.defaults
```kconfig
CONFIG_FREERTOS_HZ=1000

CONFIG_PARTITION_TABLE_CUSTOM=y
CONFIG_PARTITION_TABLE_CUSTOM_FILENAME="custom.csv"
CONFIG_PARTITION_TABLE_FILENAME="custom.csv"
```
